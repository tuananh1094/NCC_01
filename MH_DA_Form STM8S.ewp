# IAR project MH_DA_Form STM8S.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C4 STM8S105C4
  General.GenCodeModel: 2
  General.GenDataModel: 2
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105C4
  ICCSTM8.CCIncludePath2: Main; FWLib\Include; User\Include; UserSTM8\Include
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: MH_DA_Form STM8S.hex
  ILINK.IlinkOutputFile: MH_DA_Form STM8S.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  General.GenCodeModel: 0
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group FWLib
    FWLib/Source/: stm8s_clk.c stm8s_flash.c stm8s_iwdg.c stm8s_tim2.c stm8s_tim4.c
  group Main
    Main/: main.c
  group User
    User/Source/: process.c
  group UserSTM8S
    UserSTM8/Source/: user_delay.c user_eeprom.c user_gpio.c user_iwdg.c user_timer.c
